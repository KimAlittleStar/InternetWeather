# Keil uVision project Template.uvprojx, settings and files
target Project (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,RTE_CMSIS_RTOS_RTX
  c include: .\Source\Main;.\Source\DeBug_UI;.\Source\Data_Process;.\Source\Device_Basic\Inc;.\Source\Device_Basic\Src;.\Source\HardWare_Core\CMSIS;.\Source\HardWare_Core\CMSIS\startup;.\Source\HardWare_Core\CMSIS\startup\arm;.\Source\HardWare_Core\CMSIS\startup\gcc_ride7;.\Source\HardWare_Core\CMSIS\startup\iar;.\Source\HardWare_Core\CMSIS\startup\TrueSTUDIO;.\Source\HardWare_Lib\FWlib\inc;.\Source\HardWare_Lib\FWlib\src;.\Source\FatFile;.\Source\UCOSII_core;.\Source\UCOSII_Port;.\Source\OS_APP
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Main
    ./Source/Main/: MAIN.c delay.c sys.c
  group OS_APP
    ./Source/OS_APP/: os_app.c
  group Device_basic
    ./Source/Device_Basic/Src/: _VNIC.c KeyScan.c UsartDrive.c FlashDrive.c LCDDrive.c SPIDrive.c StmFlash.c WIFIDrive.c timer.c usart3.c TimerDriver.c UTDrive.c fontupd.c text.c
  group Data_Process
    ./Source/Data_Process/: malloc.c stirng_Process.c
  group Hardward_core
    ./Source/HardWare_Core/CMSIS/: stm32f10x_it.c core_cm3.c system_stm32f10x.c
    ./Source/HardWare_Core/CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group Hardward_lib
    ./Source/HardWare_Lib/FWlib/src/: misc.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_spi.c
  group FatFile
    ./Source/FatFile/: diskio.c ff.c ffsystem.c ffunicode.c
  group UCOSII_core
    ./Source/UCOSII_core/: os_core.c os_dbg_r.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII_port
    ./Source/UCOSII_Port/: os_cpu_a.asm os_cpu_c.c os_cfg.h
